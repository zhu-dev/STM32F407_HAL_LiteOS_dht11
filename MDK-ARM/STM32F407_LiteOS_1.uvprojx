# Keil uVision project STM32F407_LiteOS_1.uvprojx, settings and files
target STM32F407_LiteOS_1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407_LiteOS_1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\LiteOS\arch\arm\arm-m\include;..\LiteOS\kernel\include;..\LiteOS\kernel\base\include;..\LiteOS\kernel\extended\include;..\LiteOS\OS_CONFIG;..\Hardware\DHT11;..\Hardware\sys
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f4xx.c
  group LiteOS/kernel
    ../LiteOS/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../LiteOS/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../LiteOS/kernel/base/misc/: los_misc.c
    ../LiteOS/kernel/base/om/: los_err.c
    ../LiteOS/kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../LiteOS/kernel/base/mem/common/: los_memcheck.c los_memstat.c los_slab.c los_slabmem.c
    ../LiteOS/kernel/base/mem/membox/: los_membox.c
    ../LiteOS/kernel/extended/tickless/: los_tickless.c
    ../LiteOS/kernel/: los_init.c
  group LiteOS/Arch
    ../LiteOS/arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
    ../LiteOS/arch/arm/arm-m/cortex-m4/keil/: los_dispatch_keil.S
  group LiteOS/Config
    ../LiteOS/OS_CONFIG/: los_builddef.h los_printf.h target_config.h
  group Hardware
    ../Hardware/DHT11/: dht11.c
    ../Hardware/sys/: sys.c
software components: CMSIS:CORE 5.0.1
